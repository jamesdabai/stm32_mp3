# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucosiii +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\UCOSIII\EvalBoards\ST\STM32F429II-SK\BSP;..\UCOSIII\EvalBoards\ST\STM32F429II-SK\uCOS-III;..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOSIII\uCOS-III\Source;..\HARDWARE;..\HARDWARE\SDIO;..\HARDWARE\DMA;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\MP3;..\MP3\pub;..\MP3\real;..\MP3\real\arm;..\HARDWARE\LCD;..\HARDWARE\SPI;..\FWLIB\src;..\HARDWARE\DAC;..\HARDWARE\TIMER;..\HARDWARE\TEXT;..\HARDWARE\PICTURE;..\UCOSIII\EvalBoards\ST\STM32F429II-SK\BSP\TrueSTUDIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/: dev_uart.c dev_uart.h dev_key.c dev_time.c ddi.h dev_key.h dev_time.h
    ../HARDWARE/SDIO/: sdio_sdcard.c sdio_sdcard.h
    ../HARDWARE/DMA/: dma.c dma.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../HARDWARE/DAC/: dac.h dac.c
    ../HARDWARE/TIMER/: timer.h timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_fsmc.c
    ../FWLIB/inc/: misc.h stm32f4xx_adc.h stm32f4xx_dac.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_flash.h stm32f4xx_gpio.h stm32f4xx_pwr.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_syscfg.h stm32f4xx_spi.h stm32f4xx_tim.h
  group APP
    ../UCOSIII/EvalBoards/ST/STM32F429II-SK/uCOS-III/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../UCOSIII/EvalBoards/ST/STM32F429II-SK/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group uC/CPU
    ../UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII/Port
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII/Source
    ../UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group Malloc
    ../MALLOC/: malloc.c malloc.h
  group FATFS
    ../FATFS/exfuns/: exfuns.c exfuns.h fattester.c fattester.h
    ../FATFS/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../FATFS/src/option/: cc936.c
  group MP3
    ../MP3/: mp3player.c mp3dec.c mp3tabs.c audio_common.c audio_mp3.c audio_mp3_rom.c audio_wav.c
    ../MP3/real/arm/: asmmisc.s asmpoly_thumb2.s
    ../MP3/real/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../MP3/pub/: statname.h mpadecobjfixpt.h mp3dec.h mp3common.h
  group LCD
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TEXT/: fontupd.c text.c
software components: CMSIS:CORE 5.2.0
